;
; 配合"4個七段式LED實習板"
;  在4個七段式LED上顯示數字"1234"
;
START:
	MOV	R2,#0
LOOP:
	MOV	P1,#0FFH   ;  關閉共陽

	MOV	A,R2
	INC	A
	MOV	DPTR,#SSTBL
	MOVC	A,@A+DPTR
	MOV	P0,A

	MOV	A,R2
	MOV	DPTR,#LOC
	MOVC	A,@A+DPTR
	MOV	P1,A

	INC	R2
	CJNE	R2,#4,NEXT1
	MOV	R2,#0
NEXT1:
	ACALL	DELAY1MS
	AJMP	LOOP

	$include (delay.inc)

SSTBL:
	DB	0C0H
	DB	0F9H
	DB	0A4H,0B0H,099H
	DB	092H,082H,0F8H,080H,090H
LOC:
	DB	0F7H,0FBH,0FDH,0FEH
	END
