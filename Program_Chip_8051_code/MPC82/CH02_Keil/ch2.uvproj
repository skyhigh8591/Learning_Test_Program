# Keil uVision project ch2.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516A Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x3FFF) CLOCK(45000000)
  output: ch2 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: LED.C
