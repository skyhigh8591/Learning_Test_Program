# Keil uVision project SPI_SD.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(12000000)
  output: SPI_SD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SPI_SD1.C SD.c
