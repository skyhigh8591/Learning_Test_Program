;
; 找出兩個8位元數中的較大值(signed view) 
;
	DSEG	AT 40H
VAL1:	DS	1
VAL2:	DS	1
RES:	DS	1

	CSEG
START:
	MOV	A,VAL1
	JB	ACC.7,VAL1N
; VAL1 is 正數
	MOV	A,VAL2
	JB	ACC.7,VAL1G
; VAL1和VAL2同號
VAL12SS:
	MOV	A,VAL1
	CLR	C
	SUBB	A,VAL2
	JB	ACC.7,VAL2G
VAL1G:
	MOV	A,VAL1
	MOV	RES,A
	AJMP	CON
VAL1N:
	MOV	A,VAL2
	JB	ACC.7,VAL12SS
VAL2G:
	MOV	A,VAL2
	MOV	RES,A
CON:
	AJMP	$
	END
