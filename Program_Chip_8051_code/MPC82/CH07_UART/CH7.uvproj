# Keil uVision project CH7.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x3FF) CLOCK(12000000)
  output: CH7 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: UART1.C 7_1.C UART8.C
