# Keil uVision project controlNvic.uvprojx, settings and files
target STM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: controlNvic
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group main
    ./: controlNvic_main.c usart_user.c
software components: CMSIS:CORE 5.1.1, Compiler:I/O:STDOUT 1.4.0, Device:Startup 2.2.3
